# Keil uVision project LY-STM32.uvproj, settings and files
target LY-STM32 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LY-STM32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR;.\ModBus\include;.\ModBus\rtu;.\Port
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c pbdata.c stm32f10x_it.c time.c myrtu.c usart.c dealdata.c watchdog.c ad.c beep.c disdata.c ds1340.c ds1340iic.c lcd.c lcdiic.c led.c sht10_75.c key.c tp4054.c menu.c ds18b20.c ioinput.c wifi.c storedata.c spi.c w25q64.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_pwr.c
  group System
    ./System/: system_stm32f10x.c
  group ModBus
    ./ModBus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./ModBus/rtu/: mbcrc.c mbrtu.c
    ./ModBus/: mb.c
  group Port
    ./Port/: portevent.c portserial.c porttimer.c
